Commit message: removed FB joint offset

File: kyon_urdf/urdf/kyon.urdf.xacro (robot description, xacro)
@@ -13,5 +13,5 @@
 		<parent link="world"/>
 		<child link="pelvis"/>
-		<origin xyz="0 0 0.6"/>
+		<origin xyz="0 0 0"/>
 	</joint>
 </xacro:if>
